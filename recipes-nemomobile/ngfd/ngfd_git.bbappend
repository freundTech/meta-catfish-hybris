RDEPENDS_${PN}_append_catfish = " ngfd-plugin-droid-vibrator "
