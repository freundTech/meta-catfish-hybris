FILESEXTRAPATHS_prepend_catfish := "${THISDIR}/usb-moded:"
