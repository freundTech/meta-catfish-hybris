RDEPENDS_${PN}_append_catfish = " qt5-qpa-hwcomposer-plugin "
