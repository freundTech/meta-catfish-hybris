FILESEXTRAPATHS_prepend_catfish := "${THISDIR}/${PN}:"
COMPATIBLE_MACHINE_catfish = "catfish"
