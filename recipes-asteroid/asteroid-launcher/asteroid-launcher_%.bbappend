FILESEXTRAPATHS_prepend_catfish := "${THISDIR}/asteroid-launcher:"
SRC_URI_append_catfish = " file://default.conf"
